# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Common;..\DIO\includes;..\GPTM\includes
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../DIO/: DIO.c
    ../DIO/includes/: DIO_Types.h DIO.h
    ../GPTM/: GPTM.c
    ../GPTM/includes/: GPTM.h GPTM_Types.h
    ../Common/: Std_Types.h MCU_HardWare.h BIT_MATH.h
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
